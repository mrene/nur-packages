options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: oqpsk_sniffer
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: IEEE 802.15.4 Sniffer
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '{ i: 1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)}[channel]'
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna
    short_id: A
    type: str
    value: ''
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: channel
  id: parameter
  parameters:
    label: Channel
    short_id: c
    type: intx
    value: '15'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device
    short_id: d
    type: str
    value: ''
  states: {}
- name: device_args
  id: parameter
  parameters:
    label: Device args
    short_id: a
    type: str
    value: ''
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    short_id: g
    type: eng_float
    value: '0.75'
  states: {}
- name: ieee802_15_4_oqpsk_phy_0
  id: ieee802_15_4_oqpsk_phy
  parameters: {}
  states: {}
- name: output
  id: parameter
  parameters:
    label: Output file
    short_id: o
    type: str
    value: /tmp/sensor.pcap
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    balance0: '0'
    bw0: '4000000'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: device
    dev_args: device_args
    devname: custom
    overall_gain0: gain
    samp_rate: '4000000'
    type: fc32
  states: {}

connections:
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, '0', blocks_null_sink_0, '0']
- [ieee802_15_4_oqpsk_phy_0, rxout, foo_wireshark_connector_0, in]
- [soapy_source_0, '0', ieee802_15_4_oqpsk_phy_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
